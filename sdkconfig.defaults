## sdkconfig.defaults
```kconfig
# fix for build issue
CONFIG_FREERTOS_HZ=1000

# Enable LVGL benchmark demo
CONFIG_LV_USE_DEMO_BENCHMARK=y
```
